# Keil uVision project 16_Timer0_and_Timer_1.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 16_Timer0_and_Timer_1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: timer.h timer.c type.h type.c 16_Main.c
software components: CMSIS:CORE 5.6.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
